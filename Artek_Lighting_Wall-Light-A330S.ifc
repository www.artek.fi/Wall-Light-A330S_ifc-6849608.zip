Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-09-28T20:04:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 28 20:04:39 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{7E4DBD5D-2596-4D9E-AE04-C06306AA2830}\ifc * Database version: 5507 * Database creation date: Wed Sep 28 20:04:39 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 28 20:04:39 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 28 20:04:39 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Wall Light A330S "Golden Bell" brass, polish and clear lacquer, Artek_Lighting_Wall-Light-A330S:Wall Light A330S "Golden Bell" brass, polish and clear lacquer:9637
In: Level 1
Type - Material: Brass
Type - Constraints - DefaultElevation: 0 mm; NominalVoltageCalc: 0 V
Type - Dimensions - Light Source Symbol Size: 609.6 mm; NominalLength: 480 mm; NominalRadius: 285 mm; NominalWidth: 170 mm
Type - General - BIMObjectName: Artek_Lighting_Wall-Light-A330S; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: General purpose luminaires; NBSReference: 90-60-50/405; ProductInformation: Wall Light A330S “Golden Bell” is a complement to Alvar Aalto’s popular sculptural pendant light. Its perforated rim creates a memorable halo effect and prevents glare, providing a light that is both warm-toned and characteristically diffuse. Affixed via a slender arm, it can be rotated through 180 degrees allowing for varying intensities of illumination. Available in handspun brass, or powder-coated steel in either black or white, “Golden Bell” Wall Light is an elegant reading light next to a bed, sofa, armchair or desk or warmly illuminates a kitchen table.; Revision: n/a; Uniclass2: Pr_70_70_49_86; Uniclass2015Description: General purpose luminaires; Uniclass2015Reference: Pr_70_70_48_62; Version: 1; VersionDate: 27/09/2022
Type - Identity Data - Collection: Pendant Lights; Description: Wall Light A330S “Golden Bell” is a complement to Alvar Aalto’s popular sculptural pendant light. Its perforated rim creates a memorable halo effect and prevents glare, providing a light that is both warm-toned and characteristically diffuse. Affixed via a slender arm, it can be rotated through 180 degrees allowing for varying intensities of illumination. Available in handspun brass, or powder-coated steel in either black or white, “Golden Bell” Wall Light is an elegant reading light next to a bed, sofa, armchair or desk or warmly illuminates a kitchen table.; Designer: Alvar Aalto; Manufacturer: Artek; Model: Wall Light A330S "Golden Bell" brass, polish and clear lacquer; OmniClass Number: 23.80.70.00; OmniClass Title: Lighting; Type Name: Wall Light A330S "Golden Bell" brass, polish and clear lacquer; URL: https://www.artek.fi/en/products/wall-light-a330s-golden-bell
Type - Materials and Finishes - LightFixtureMainMaterial: Brass
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; Category: Lighting; CodePerformance: n/a; Color: White; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Artek_Lighting_Wall-Light-A330S; Features: Wall Light A330S' swivel arm is perfect when flexibility is needed; Finish: brass, polish and clear lacquer; Grade: n/a; Material: Base and stand:Steel, covered with leather Tube versions:Brass, Stainless steel Shade:Hand-riveted louvered steel; ModelNumber: 29101601; ModelReference: n/a; Name: Wall-Light-A330S; ReplacementCost: n/a; Shape: Sculptured; Size: 175x480x255 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Illuminance: 11.8206 lx; Initial Color: 0; Initial Color Temperature: 3000 K; Initial Intensity: 0; Light Loss Factor: 0; Light Source Definition (family): Point+Spherical; Luminous Flux: 1380 lm; Luminous Intensity: 109.817 cd; Total Light Loss Factor: 1; Wattage: 9.2903 W
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.830427 m2; NominalHeight: 254 mm; Volume: 0.13934 m3
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Lighting Fixtures; Family: Artek_Lighting_Wall-Light-A330S: Wall Light A330S "Golden Bell" brass, polish and clear lacquer; Family and Type: Artek_Lighting_Wall-Light-A330S: Wall Light A330S "Golden Bell" brass, polish and clear lacquer; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek_Lighting_Wall-Light-A330S: Wall Light A330S "Golden Bell" brass, polish and clear lacquer; Type Id: Artek_Lighting_Wall-Light-A330S: Wall Light A330S "Golden Bell" brass, polish and clear lacquer; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
